start:
	lcd #0x01
	lcd #0x0c

date:
	lcd #0xff
	out.d #20

	; Year
	rtr #0x05,0x40,0x41
	jsr out_date

	; Month
	rtr #0x04,0x40,0x41
	jsr out_date

	; Day
	rtr #0x03,0x40,0x41
	jsr out_date

time:
	lcd #0xA7

	; Hour
	rtr #0x02,0x40,0x41
	jsr out_time

	; Min
	rtr #0x01,0x40,0x41
	jsr out_time

	; Sec
	rtr #0x00,0x40,0x41
	jsr out_time

	lda 0x40
	adc 0x41
	beq date
	jmp time

out_date:
	out.d 0x40
	out.d 0x41
	out.c #0x2E
	rts

out_time:
	out.c #0x3A
	out.d 0x40
	out.d 0x41
	rts